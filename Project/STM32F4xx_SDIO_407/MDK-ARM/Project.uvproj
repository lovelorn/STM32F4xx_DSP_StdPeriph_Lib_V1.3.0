# Keil uVision project Project.uvproj, settings and files
target STM32F429_439xx (ARM-ADS)
  device: STM32F439II STMicroelectronics
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429_439xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,USE_STM324x9I_EVAL,
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM324x9I_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group CMSIS
    ../UserApp/: system_stm32f4xx.c
  group Doc
    ./: readme.txt
  group MDK-ARM
    ../../../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xx.s startup_stm32f427_437xx.s startup_stm32f40_41xxx.s startup_stm32f429_439xx.s
  group STM32F4xx_StdPeriph_Driver
    ../../../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_can.c stm32f4xx_cryp.c stm32f4xx_cryp_des.c stm32f4xx_dac.c stm32f4xx_dcmi.c stm32f4xx_dma2d.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_hash.c stm32f4xx_hash_sha1.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_sai.c stm32f4xx_spi.c stm32f4xx_tim.c stm32f4xx_wwdg.c stm32f4xx_adc.c stm32f4xx_cryp_aes.c stm32f4xx_dbgmcu.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_i2c.c stm32f4xx_rcc.c stm32f4xx_sdio.c stm32f4xx_usart.c stm32f4xx_crc.c stm32f4xx_dma.c stm32f4xx_hash_md5.c stm32f4xx_rtc.c stm32f4xx_cryp_tdes.c stm32f4xx_ltdc.c stm32f4xx_syscfg.c stm32f4xx_fmc.c
  group User
    ../UserApp/: main.c stm32f4xx_it.c
    ../../../Utilities/STM32_EVAL/STM3240_41_G_EVAL/: stm324xg_eval.c stm324xg_eval_sdio_sd.c
  group HAL
    ../../../Libraries/HAL_CGC/: Usart.c RTC.c LCD.c
  group Fatfs
    ../../../Libraries/HAL_CGC/: fatfs_drv.c
    ../../../Utilities/Third_Party/fat_fs/src/: ff.c
    ../../../Utilities/Third_Party/fat_fs/src/option/: syscall.c
  group ucosii
    ../../../Utilities/Third_Party/ucos_ii/source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
    ../../../Utilities/Third_Party/ucos_ii/port/: os_cpu_a.asm os_cpu_c.c os_dbg_r.c
target STM32F427_437xx (ARM-ADS)
  device: STM32F437II STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x8100000) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F427_437xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F427_437xx,USE_STM324x7I_EVAL,
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM324x7I_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100001
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_suppress=L6329
target STM32F40_41xxx (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F40_41xxx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM324xG_EVAL,
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL;..\..\..\Libraries\HAL_CGC;..\..\..\Utilities\Third_Party\fat_fs\inc;..\..\..\Utilities\Third_Party\ucos_ii\port;..\..\..\Utilities\Third_Party\ucos_ii\source;..\UserApp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
target STM32F401xx (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: as above
  output: STM32F401xx
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,USE_STM324xG_EVAL
  c misc: --C99
  c include: ..\;..\..\..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\..\..\Utilities\STM32_EVAL\Common;..\..\..\Utilities\STM32_EVAL\STM3240_41_G_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
